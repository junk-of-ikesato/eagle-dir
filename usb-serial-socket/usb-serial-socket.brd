# Repository junk-of-ikesato/eagle-dir

## EAGLE design usb-serial-socket/usb-serial-socket.brd

Parts:
C1: C-EU025-024X044; C025-024X044
JP1, JP2: PINHD-1X12; 1X12
X1: TYPE-A-FEMALE

Connections:
unnamed: JP1.1, X1.D+
unnamed: JP1.5, X1.D-
unnamed: C1.1, X1.S2
unnamed: JP2.12, X1.GND
unnamed: JP2.9, X1.VCC
unnamed: C1.2, JP1.2

Board: 2 copper layers, 40.6 x 20.3 mm, 4 parts (0 on the bottom side), 6 nets.

## EAGLE design tqfp44/tqfp44.brd

Parts:
IC1: ATMEGA32U4-AU; TQFP44
JP1, JP2, JP3, JP4: THROUHOLE11

Connections:
AREF: IC1.42 (AREF), JP4.9
AVCC: IC1.24 (AVCC), JP3.2
AVCC1: IC1.44 (AVCC1), JP4.11
D+: IC1.4 (D+), JP1.4
D-: IC1.3 (D-), JP1.3
GND: IC1.15 (GND), JP2.4
GND1: IC1.23 (GND1), JP3.1
GND2: IC1.35 (GND2), JP4.2
GND3: IC1.43 (GND3), JP4.10
PB0: IC1.8 (PB0(SS)), JP1.8
PB1: IC1.9 (PB1(SCK)), JP1.9
PB2: IC1.10 (PB2(PDI/MOSI)), JP1.10
PB3: IC1.11 (PB3(PDO/MISO)), JP1.11
PB4: IC1.28 (PB4(ADC11)), JP3.6
PB5: IC1.29 (PB5(OC1A/ADC12/!OC4B)), JP3.7
PB6: IC1.30 (PB6(OC1B/OC4B/ADC13)), JP3.8
PB7: IC1.12 (PB7(OC0A/OC1C/RTS)), JP2.1
PC6: IC1.31 (PC6(OC3A/!OC4A)), JP3.9
PC7: IC1.32 (PC7(ICP3/CLK0/OC4A)), JP3.10
PD0: IC1.18 (PD0(INT0/OC0B/SCL)), JP2.7
PD1: IC1.19 (PD1(INT1/SDA)), JP2.8
PD2: IC1.20 (PD2(INT2/RXD1)), JP2.9
PD3: IC1.21 (PD3(INT3/TXD1)), JP2.10
PD4: IC1.25 (PD4(ICP1/ADC8)), JP3.3
PD5: IC1.22 (PD5(XCK/CTS)), JP2.11
PD6: IC1.26 (PD6(T1/ADC9/!OC4D)), JP3.4
PD7: IC1.27 (PD7(OC4D/ADC10/T0)), JP3.5
PE2: IC1.33 (PE2(!HWB)), JP3.11
PE6: IC1.1 (PE6(INT.6/AIN0)), JP1.1
PF0: IC1.41 (PF0(ADC0)), JP4.8
PF1: IC1.40 (PF1(ADC1)), JP4.7
PF4: IC1.39 (PF4(ADC4/TCK)), JP4.6
PF5: IC1.38 (PF5(ADC5/TMS)), JP4.5
PF6: IC1.37 (PF6(ADC6/TDO)), JP4.4
PF7: IC1.36 (PF7(ADC7(TDI)), JP4.3
RESET: IC1.13 (/RESET), JP2.2
UCAP: IC1.6 (UCAP), JP1.6
UGND: IC1.5 (UGND), JP1.5
UVCC: IC1.2 (UVCC), JP1.2
VBUS: IC1.7 (VBUS), JP1.7
VCC: IC1.14 (VCC), JP2.3
VCC1: IC1.34 (VCC1), JP4.1
XTAL1: IC1.17 (XTAL1), JP2.6
XTAL2: IC1.16 (XTAL2), JP2.5

Board: 2 copper layers, 20.3 x 20.3 mm, 5 parts (0 on the bottom side), 44 nets.

## EAGLE design i2c-7segled/buttons-DIP.brd

Parts:
JP3: switch left; 1X02
JP4: switch right; 1X02
SW1, SW2, SW3: TVBP060.3INCH-PITCH; TVBP06-0.3INCH

Connections:
GND: JP4.2, SW1.1, SW2.1, SW3.1
unnamed: JP3.1, SW1.2
unnamed: JP3.2, SW2.2
unnamed: JP4.1, SW3.2

Board: 2 copper layers, 38.1 x 7.6 mm, 5 parts (0 on the bottom side), 4 nets.

## EAGLE design frisk-led-test/frisk-led-test.brd

Parts:
C1: 0.1u; C025-024X044
C2: 0.47u; C075-032X103
IC1: PIC18F14K50P; DIL20
JP1: PINHD-1X2; 1X02
LED1: SML-02
R1: 100; 0204/7
R2: 150 or 180; 0204/7
R3: 10k; 0204/7
SW1: TVBP06
U$1: TYPE-A+SHILED; TYPE-A
XTAL1: CSTCE12M0G15L; CSTCE

Connections:
+5V: C1.1, IC1.1 (VDD), R3.2, U$1.VCC (1)
GND: C1.2, C2.1, IC1.20 (VSS), LED1.1 (CC1), LED1.3 (CC2), SW1.1, U$1.GND (4), XTAL1.2 (GND)
unnamed: LED1.2 (AB), R1.1
unnamed: LED1.4 (AR), R2.1
unnamed: IC1.3 (RA4/OSC2), XTAL1.3 (RIT)
unnamed: IC1.2 (RA5/OSC1), XTAL1.1 (LFT)
unnamed: IC1.8 (RC6/AN8), R1.2
unnamed: IC1.19 (RA0/D+), U$1.D+ (3)
unnamed: IC1.18 (RA1/D-), U$1.D- (2)
unnamed: IC1.9 (RC7/AN9), R2.2
unnamed: IC1.4 (RA3/!MCLR!), JP1.1, R3.1, SW1.2
unnamed: C2.2, IC1.17 (VUSB)
unnamed: JP1.2, U$1.SHEELD (5)

Board: 2 copper layers, 66.0 x 27.4 mm, 11 parts (2 on the bottom side), 13 nets.

## EAGLE design i2c-7segled/buttons.brd

Parts:
JP3, JP4: PINHD-1X2; 1X02
SW1, SW2, SW3: ALPS-4.2X3.2MM

Connections:
GND: JP4.2, SW1.2 (P1), SW2.1, SW3.2 (P1)
unnamed: JP3.1, SW1.3 (S)
unnamed: JP3.2, SW2.3 (S)
unnamed: JP4.1, SW3.4 (S1)

Board: 2 copper layers, 38.1 x 6.3 mm, 5 parts (0 on the bottom side), 4 nets.

## EAGLE design usb-shock-buzzer3/usb-shock-buzzer.brd

Parts:
C1, C7: 4.7u; C0805
C2: 0.22u; C0805
C4, C5, C6: 0.1u; C0805
CON1: PH-2PIN
IC1: PIC18F14K50; SO20
IC2: ADXL213; LCC8
IC3: AE-NJU72501
IC4: MCP73831; SOT23-5L
IC5: CAT24M01; SOIC
IC6: MAX882SA; 8-SO
JP4: PINHD-1X2; 1X02
JP5: PINHD-2X2; 2X02
LED1: AYBG1202W
LED2: 2COLOR-BR; SML-02
R1: 2.2k; M0805
R2, R3, R7: 10k; M0805
R4, R12: 1M; R0805
R5: 150k; M0805
R6: 470k; M0805
R9: 220k?; M0805
R10: 1k; M1206
R11: 1470; R0805
R13, R14, R15, R16: 500?; M0805
SP1: PKLCS1212E4001
SW1: TVBP06
USB: TYPE-A+SHILED; TYPE-A
XTAL1: 12MHz; CSTCE

Connections:
BATTERY+: C7.1, CON1.1, IC4.3 (VBAT), IC6.5 (IN), IC6.8 (LBI), R3.2, R11.2
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, CON1.2, IC1.20 (VSS), IC2.3 (COM), IC3.2 (GND1), IC3.4 (GND2), IC4.2 (VSS), IC5.2 (A1), IC5.3 (A2), IC5.4 (GND), IC5.7 (WP), IC6.3 (GND), IC6.6 (GND), LED1.2 (CC1), LED1.4 (CC2), LED2.1 (CC1), LED2.3 (CC2), R1.2, R2.1, R6.1, R9.2, R12.1, SW1.1, USB.GND (4), XTAL1.2 (GND)
unnamed: IC3.6 (EN1), JP5.2
unnamed: IC1.18 (RA1/D-), USB.D- (2)
unnamed: IC1.19 (RA0/D+), USB.D+ (3)
unnamed: IC4.5 (PROG), R1.1
unnamed: IC1.16 (RC0/AN4), IC4.1 (STAT)
unnamed: JP4.1, USB.SHEELD (5)
unnamed: C2.1, IC1.17 (VUSB)
unnamed: IC1.7 (RC3/AN7), R2.2, R3.1
unnamed: R4.1, R5.2
unnamed: IC1.11 (RB6), IC5.6 (SCL)
unnamed: IC1.13 (RB4/AN10), IC5.5 (SDA)
unnamed: C5.1, IC2.6 (YFILT)
unnamed: C6.1, IC2.7 (XFILT)
unnamed: IC1.9 (RC7/AN9), IC2.5 (XOUT)
unnamed: IC1.10 (RB7/TX), IC2.4 (YOUT)
unnamed: IC3.5 (EN2), JP5.4
unnamed: IC2.2 (T2), R9.1
unnamed: IC3.8 (VO1), R10.1, SP1.1
unnamed: IC3.7 (VO2), R10.2, SP1.2
unnamed: IC1.4 (RA3/!MCLR!), JP4.2, R7.1, SW1.2
unnamed: LED1.1 (A1), R13.1
unnamed: LED1.3 (A2), R14.1
unnamed: LED2.4 (AR), R16.1
unnamed: IC1.15 (RC1/AN5), IC3.3 (DIN)
unnamed: IC1.2 (RA5/OSC1), XTAL1.3 (RIT)
unnamed: IC1.14 (RC2/AN6), R15.2
unnamed: IC1.3 (RA4/OSC2), XTAL1.1 (LFT)
unnamed: IC6.2 (SET), R5.1, R6.2
unnamed: IC1.5 (RC5/CCP1), R13.2
unnamed: IC1.6 (RC4/P1B), R14.2
unnamed: IC1.12 (RB5/RX), R16.2
unnamed: LED2.2 (AB), R15.1
unnamed: IC6.7 (OFF/STBY), R11.1, R12.2
USB_VCC: C1.1, IC4.4 (VDD), USB.VCC (1)
VCC: C4.1, IC1.1 (VDD), IC2.8 (VDD), IC3.1 (VIN), IC5.8 (VCC), IC6.4 (OUT), JP5.1, JP5.3, R4.2, R7.2

Notes on the sheet:
OUT には 4V 流したい。 SETにかける抵抗は以下で計算する。 4 = 1.2 * (R4+R5+R6)/R6 3V を下回ったら回路を停止したい。 STBYにかける抵抗は以下で計算する。 3 = 1.2 * (R11+R12)/R12 R12=1Mとすると R11=1500 R11=1470とすると 1.2 * (1470+1000)/1000 = 2.964V R4 = 1MΩ と決めてこの方程式を計算すると R5 = 166.66.. kΩ R6 = 500 kΩ 166kΩ と 500kΩ の抵抗はないから 150kΩ, 470kΩ とする R4=1M,R5=150k,R6=4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

Board: 2 copper layers, 47.0 x 27.0 mm, 36 parts (21 on the bottom side), 37 nets.

## EAGLE design 7seg-weather/wifi-power.brd

Parts:
C5: 0.1uF; C0603K
C7, C8: 4.7uF; C0603K
IC3: ESP-WROOM-02; FRONT-FACE
IC4: MCP73831; SOT23-5L
JP1, JP9, JP11: PINHD-1X4; 1X04
JP2: PINHD-1X2; 1X02
LED1: LG_T679-E1F1-1; PLCC2
R1, R2, R4, R5, R16: 10k; M0805
R3, R18: 1k; MINI_MELF-0102R
R17: 470; M0805
SW1: 2X1S-SIDE-0.1INCH; 2X1SIDE-0.1INCH
SW2: MSS-22C02

Connections:
+3.3V: C5.1, IC3.1 (3V3), JP1.2, JP11.1, R2.1, R4.2, SW2.P$1 (O), SW2.P$6 (S1)
+5V/2: C7.1, IC4.4 (VDD), JP11.2, LED1.A
GND: C5.2, C7.2, C8.2, IC3.9 (GND1), IC3.13 (GND2), IC3.18 (GND3), IC4.2 (VSS), JP1.1, JP2.2, JP11.4, R5.1, R18.1, SW2.P$3 (S)
unnamed: IC3.11 (RXD), JP1.4
unnamed: IC3.12 (TXD), JP1.3
unnamed: IC3.2 (EN), R1.1
unnamed: IC3.15 (RST), IC3.17 (IO16), R2.2
unnamed: IC3.7 (IO2), R4.1
unnamed: IC3.8 (IO0), R16.1
unnamed: IC3.6 (IO15), R5.2
unnamed: IC4.5 (PROG), R3.2
unnamed: R3.1, R18.2
unnamed: IC3.4 (IO12), JP9.3
unnamed: LED1.C, R17.2
unnamed: JP9.2, SW2.P$4 (O1)
unnamed: IC4.1 (STAT), R17.1
unnamed: R16.2, SW2.P$2
unnamed: R1.2, SW2.P$5 (P1)
unnamed: IC3.3 (IO14), JP9.1
VCC: C8.1, IC4.3 (VBAT), JP2.1, SW1.1, SW1.2 (P1)
VPP: JP9.4, JP11.3, SW1.3 (S), SW1.4 (S1)

Notes on the sheet:
L:Normal R:Prpgram

Board: 2 copper layers, 63.5 x 58.4 mm, 20 parts (0 on the bottom side), 21 nets.

## EAGLE design battery-carger/battery-charger.brd

Parts:
C7, C8: 4.7uF; C025-024X044
IC4: MCP73831; SOT23-5L
JP1, JP2, JP3: PINHD-1X2; 1X02
LED3, LED4: LED3MM
R1, R17, R18, R21: 1k; MINI_MELF-0204R
USB: MICRO-USB-ZX62R-B-5P; ZX62R-B-5P

Connections:
+5V/2: C7.1, IC4.4 (VDD), LED3.A, LED4.A, USB.5
GND: C7.2, C8.2, IC4.2 (VSS), JP1.2, JP2.2, JP3.2, R1.2, R21.1, USB.1
unnamed: LED3.K (C), R21.2
unnamed: LED4.K (C), R17.2
unnamed: R1.1, R18.1
unnamed: IC4.1 (STAT), R17.1
unnamed: IC4.5 (PROG), R18.2
VCC: C8.1, IC4.3 (VBAT), JP1.1, JP2.1, JP3.1

Board: 2 copper layers, 66.0 x 27.9 mm, 13 parts (8 on the bottom side), 8 nets.
