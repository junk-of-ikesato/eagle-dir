# Repository junk-of-ikesato/eagle-dir

## EAGLE design 7seg-weather/7seg-weather.brd

Parts:
C1, C3, C9: 0.1uF; C0603K
C2: 0.22 - 0.47uF; C0603K
C6: 47uF; C0603K
D2: DIODE-MELF-MLL41; MELF-MLL41
DIS1: SD2-401UR-A21
IC1: PIC18F14K50-SO; SO20
IC2: TA48M033F; HSOP3
JP1: PINHD-1X2; 1X02
JP3, JP4, JP5, JP6: PINHD-1X6; 1X06
JP7: PINHD-1X5; 1X05
JP8, JP10: PINHD-1X4; 1X04
LED1: LG_T679-E1F1-1; PLCC2
PIR1: D205B; 3PIN
Q1, Q2: IRLM6402; SOT23
R1, R2, R19, R20, R22, R23: 10k; M0805
R3: 100k; M0805
R6: 390k; M0805
R7: 330k; M0805
R8, R9, R10, R11, R12, R13, R14, R15: 270; M0805
R17: 470; M0805
USB: MICRO-USB-ZX62R-B-5P; ZX62R-B-5P

Connections:
+3.3V: C1.2, C6.1, C9.1, D2.A, IC1.1 (VDD), IC2.POUT (OUT), JP3.1, JP4.1, JP5.1, JP6.1, JP7.2, JP10.1, PIR1.1 (VDD), Q1.2 (S), Q2.2 (S), R22.2, R23.2
+5V/2: JP10.2, R2.2, USB.1
GND: C1.1, C2.2, C3.2, C6.2, C9.2, IC1.20 (VSS), IC2.HGND, JP7.3, JP10.4, LED1.C, PIR1.3 (GND), R1.1, R7.1, USB.5
unnamed: IC1.18 (RA1/D-), JP7.5
unnamed: IC1.13 (RB4/AN10), JP3.3
unnamed: LED1.A, R17.1
unnamed: JP1.1, R3.1
unnamed: PIR1.2 (OUT), R3.2
unnamed: IC1.3 (RA4/OSC2), R6.1, R7.2
unnamed: IC1.4 (RA3/MCLR), JP7.1, R1.2, R2.1
unnamed: C2.1, IC1.17 (VUSB)
unnamed: IC1.9 (RC7/AN9), JP8.3
unnamed: IC1.8 (RC6/AN8), R17.2
unnamed: IC1.12 (RB5/RX), JP3.2
unnamed: DIS1.P$5 (5), Q1.3 (D)
unnamed: IC1.6 (RC4/P1B), JP4.4
unnamed: IC1.10 (RB7/TX), JP8.2
unnamed: IC1.14 (RC2/AN6), JP3.4
unnamed: DIS1.P$10 (10), Q2.3 (D)
unnamed: IC1.2 (RA5/OSC1), JP4.6
unnamed: Q2.1 (G), R20.2, R23.1
unnamed: DIS1.P$3 (3), R8.2
unnamed: DIS1.P$9 (9), R9.2
unnamed: DIS1.P$8 (8), R10.2
unnamed: DIS1.P$6 (6), R11.2
unnamed: DIS1.P$7 (7), R12.2
unnamed: DIS1.P$4 (4), R13.2
unnamed: DIS1.P$1 (1), R14.2
unnamed: IC1.7 (RC3/AN7), JP4.2
unnamed: IC1.15 (RC1/AN5), JP3.5
unnamed: IC1.16 (RC0/AN4), JP3.6
unnamed: IC1.5 (RC5/CCP1), JP4.5
unnamed: Q1.1 (G), R19.2, R22.1
unnamed: DIS1.P$2 (2), R15.2
unnamed: IC1.11 (RB6), JP8.1
unnamed: IC1.19 (RA0/D+), JP1.2, JP7.4
unnamed: JP5.3, R15.1
unnamed: JP6.4, R8.1
unnamed: JP6.5, R12.1
unnamed: JP6.6, R11.1
unnamed: JP6.3, R13.1
unnamed: JP5.4, R10.1
unnamed: JP5.5, R20.1
unnamed: JP6.2, R19.1
unnamed: JP5.6, R9.1
unnamed: JP5.2, R14.1
PGND: IC2.PGND
VPP: C3.1, D2.C, IC2.PIN (IN), JP8.4, JP10.3, R6.2

Notes on the sheet:
SDA
SCL
小さい奴に変えた

Board: 2 copper layers, 166.4 x 71.1 mm, 40 parts (16 on the bottom side), 47 nets.

## EAGLE design 7seg-weather/programmer-board.brd

Parts:
JP1, JP2, JP3, JP4, JP5, JP6, JP9, JP10: PINHD-1X4; 1X04
JP7, JP8: PINHD-1X5; 1X05
JP11, JP12: PINHD-1X12; 1X12
S1: 9450-2

Connections:
unnamed: JP1.1, S1.3 (O)
unnamed: JP2.1, JP9.1, S1.2
unnamed: JP1.2, JP2.2, JP9.2
unnamed: JP1.3, JP2.3, JP9.3
unnamed: JP1.4, S1.6 (O)
unnamed: JP2.4, JP9.4, S1.5
unnamed: JP3.1, JP4.1, JP10.1
unnamed: JP3.2, JP4.2, JP10.2
unnamed: JP3.3, JP4.3, JP10.3
unnamed: JP3.4, JP4.4, JP10.4
unnamed: JP5.1, JP6.1, JP12.1
unnamed: JP5.2, JP6.2, JP12.5
unnamed: JP5.3, JP6.3, JP11.4
unnamed: JP5.4, JP6.4, JP11.1
unnamed: JP7.1, JP8.1
unnamed: JP7.2, JP8.2
unnamed: JP7.3, JP8.3
unnamed: JP7.4, JP8.4
unnamed: JP7.5, JP8.5

Board: 2 copper layers, 83.8 x 71.1 mm, 13 parts (0 on the bottom side), 19 nets.

## EAGLE design avr-remocon-botu/avr-remocon.brd

Parts:
C1: 47uF; C3216
IC1: ATTINY85; SOIC8
ILED1, ILED2, ILED3: OSI5LA5113A; LED5MM-SIDE-DOWN3
IRM: IRM2161
JP1: PINHD-1X6; 1X06
LED1: LG_T679-E1F1-1; PLCC2
Q1, Q2: IRLML6402; SOT-23
R1, R2, R3: 3.9Ω 1W; R2512W
R4: 1kΩ 1/8W; R0805
R5, R7: 2.2kΩ 1/8W; R0805
R6, R8: 10kΩ 1/8W; R0805
R9, R10, R11: 100KΩ 1/8W; R0805
SW1, SW2, SW3: RUBBER-SWITCH; HALF-PITCH

Connections:
GND: C1.2, IC1.4 (GND), ILED1.K (C), ILED2.K (C), ILED3.K (C), IRM.P$2 (GND), JP1.6, LED1.C, SW1.P2 (2), SW2.P2 (2), SW3.P2 (2)
unnamed: Q1.P3 (D), R1.2, R2.2, R3.2, R4.2
unnamed: IC1.2 ((XTAL1)PB3), R5.1
unnamed: ILED1.A, R1.1
unnamed: Q1.P1 (G), R5.2, R6.1
unnamed: ILED2.A, R2.1
unnamed: IC1.3 ((XTAL2)PB4), IRM.P$1 (VOUT)
unnamed: ILED3.A, R3.1
unnamed: LED1.A, R4.1
unnamed: IRM.P$3 (VCC), Q2.P3 (D)
unnamed: Q2.P1 (G), R7.1, R8.1
unnamed: IC1.5 ((AIN0)PB0), JP1.5, R11.1, SW3.P1 (1)
unnamed: IC1.6 ((AIN1)PB1), JP1.4, R10.1, SW2.P1 (1)
unnamed: IC1.7 ((T0)PB2), JP1.3, R9.1, SW1.P1 (1)
unnamed: IC1.1 ((RESET)PB5), JP1.2, R7.2
VCC: C1.1, IC1.8 (VCC), JP1.1, Q1.P2 (S), Q2.P2 (S), R6.2, R8.2, R9.2, R10.2, R11.2

Board: 2 copper layers, 37.3 x 89.0 mm, 24 parts (3 on the bottom side), 16 nets.

## EAGLE design esp-wroom-02/esp-wroom-02-eval-board/esp-wroom-02-eval-board.brd

Parts:
JP1, JP2: PINHD-1X9; 1X09
U$1: ESP-WROOM-02

Connections:
unnamed: JP2.9, U$1.18 (GND3)
unnamed: JP2.8, U$1.17 (IO16)
unnamed: JP2.7, U$1.16 (TOUT)
unnamed: JP2.5, U$1.15 (RST)
unnamed: JP2.6, U$1.14 (IO5)
unnamed: JP2.4, U$1.13 (GND2)
unnamed: JP2.3, U$1.12 (TXD)
unnamed: JP2.2, U$1.10 (IO4)
unnamed: JP2.1, U$1.11 (RXD)
unnamed: JP1.8, U$1.9 (GND1)
unnamed: JP1.9, U$1.8 (IO0)
unnamed: JP1.7, U$1.7 (IO2)
unnamed: JP1.6, U$1.6 (IO15)
unnamed: JP1.4, U$1.5 (IO13)
unnamed: JP1.5, U$1.4 (IO12)
unnamed: JP1.3, U$1.3 (IO14)
unnamed: JP1.2, U$1.2 (EN)
unnamed: JP1.1, U$1.1 (3V3)

Board: 2 copper layers, 27.9 x 25.4 mm, 3 parts (0 on the bottom side), 18 nets.

## EAGLE design i2c-7segled/i2c-7segled-SOIC.brd

Parts:
7SEG1: OSL40562-LR; OSL40562
C1, C3, C5: 0.1uF; C0504
C2: 0.22 - 0.47uF; C0504
C4: 10uF; C0504
G1: CR2032; HU2032
IC1: PIC18F14K50; SO20
IC2: TD62083; SO18
IC3: PCF2129AT; SO20
JP1: to PICKIT; 1X05
JP2: to RPi; 2X20
JP3: switch left; 1X02
JP4: switch right; 1X02
PAD1, PAD2, PAD3, PAD4, PAD5, PAD6, PAD7, PAD8, PAD9, PAD10, PAD11, PAD12, PAD13, PAD14, PAD15, PAD16, PAD17, PAD18, PAD19, PAD20, PAD21, PAD22, PAD23, PAD24, PAD25, PAD26, PAD27, PAD28, PAD29, PAD30, PAD31, PAD32, PAD33, PAD34, PAD35, PAD36, PAD37, PAD38, PAD39, PAD40, PAD41, PAD42, PAD43, PAD44, PAD45, PAD46, PAD47, PAD48, PAD49, PAD50, PAD51, PAD52, PAD53, PAD54, PAD55, PAD56, PAD57, PAD58, PAD59, PAD60, PAD61, PAD62, PAD63, PAD64, PAD65, PAD66, PAD67, PAD68, PAD69, PAD70, PAD71, PAD72, PAD73, PAD74, PAD75, PAD76, PAD77, PAD78, PAD79, PAD80: 1,6/0,9
R1, R2, R3, R4, R5, R6, R7, R8: 270Ω; M0805
R9: 300Ω; M0805

Connections:
+5V: C1.1, IC1.1 (VDD), JP1.2, JP2.1, PAD1.1, R9.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, G1.-, IC1.20 (VSS), IC2.9 (GND), IC3.2 (SDI), IC3.8 (VSS), JP1.3, JP2.10, JP4.2, PAD73.1
unnamed: 7SEG1.6 (CA), IC2.18 (O1)
unnamed: C3.1, IC3.5 (IFS), IC3.18 (BBS)
unnamed: C2.1, IC1.17 (VUSB)
unnamed: IC1.12 (RB5/RX), IC2.3 (I3)
unnamed: JP2.12, JP3.2
unnamed: IC1.14 (RC2/AN6), IC2.4 (I4)
unnamed: IC1.15 (RC1/AN5), IC2.2 (I2)
unnamed: IC1.16 (RC0/AN4), IC2.1 (I1)
unnamed: C5.1, G1.+, IC3.19 (VBAT)
unnamed: 7SEG1.9 (CA), IC2.16 (O3)
unnamed: 7SEG1.8 (CA), IC2.17 (O2)
unnamed: 7SEG1.12 (CA), IC2.15 (O4)
unnamed: IC1.2 (RA5/OSC1), R1.1
unnamed: 7SEG1.11 (A), R1.2
unnamed: IC1.5 (RC5/CCP1), R5.1
unnamed: IC1.7 (RC3/AN7), R2.1
unnamed: IC1.9 (RC7/AN9), R6.1
unnamed: IC1.10 (RB7/TX), R3.1
unnamed: IC1.3 (RA4/OSC2), R7.1
unnamed: IC1.6 (RC4/P1B), R4.1
unnamed: IC1.8 (RC6/AN8), R8.1
unnamed: 7SEG1.7 (B), R5.2
unnamed: 7SEG1.4 (C), R2.2
unnamed: 7SEG1.2 (D), R6.2
unnamed: 7SEG1.1 (E), R3.2
unnamed: 7SEG1.10 (F), R7.2
unnamed: 7SEG1.5 (G), R4.2
unnamed: 7SEG1.3 (DP), R8.2
unnamed: IC1.4 (RA3/MCLR), JP1.1
unnamed: IC1.19 (RA0/D+), JP1.4, JP3.1
unnamed: IC1.18 (RA1/D-), JP1.5
unnamed: IC1.11 (RB6), IC3.1 (SCL), JP2.6
unnamed: JP2.8, JP4.1
unnamed: C4.1, IC3.20 (VDD), R9.1
SCL: IC1.13 (RB4/AN10), IC3.4 (SDA/CE), JP2.4

Notes on the sheet:
SDA

Board: 2 copper layers, 65.0 x 56.0 mm, 104 parts (18 on the bottom side), 37 nets.

Other parts of the board:
U$2: KOOZYT-LOGO-WAKU-10MM

## EAGLE design rpi-clock/rpi-clock-33v.brd

Parts:
C1: 10uF; C0504
C2, C3: 0.1uF; C0504
G1: CR2032; HU2032
IC1: PCF2129AT; SO20
JP: to RPI; 1X05
R1: 330Ω; M0805

Connections:
+3V: JP.1, R1.2
GND: C1.2, C2.2, C3.2, G1.-, IC1.2 (SDI), IC1.8 (VSS), JP.5
unnamed: C1.1, IC1.20 (VDD), R1.1
unnamed: C3.1, IC1.5 (IFS), IC1.18 (BBS)
unnamed: C2.1, G1.+, IC1.19 (VBAT)
unnamed: IC1.1 (SCL), JP.3
SCL: IC1.4 (SDA/CE), JP.2

Board: 2 copper layers, 33.0 x 27.9 mm, 7 parts (2 on the bottom side), 7 nets.
