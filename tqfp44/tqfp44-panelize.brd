# Repository junk-of-ikesato/eagle-dir

## EAGLE design tqfp44/tqfp44-panelize.brd

Board: 2 copper layers, 71.1 x 35.6 mm, 25 parts (0 on the bottom side), 220 nets.

Parts:
IC1, IC2, IC3, IC4, IC5: ATMEGA32U4-AU; TQFP44
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9, JP10, JP11, JP12, JP13, JP14, JP15, JP16, JP17, JP18, JP19, JP20: THROUHOLE11

Connections:
AREF: IC1.42, JP4.9
AREF1: IC2.42, JP8.9
AREF2: IC3.42, JP12.9
AREF3: IC4.42, JP16.9
AREF4: IC5.42, JP20.9
AVCC: IC1.24, JP3.2
AVCC1: IC1.44, JP4.11
AVCC2: IC2.24, JP7.2
AVCC3: IC2.44, JP8.11
AVCC4: IC3.24, JP11.2
AVCC5: IC3.44, JP12.11
AVCC6: IC4.24, JP15.2
AVCC7: IC4.44, JP16.11
AVCC8: IC5.24, JP19.2
AVCC9: IC5.44, JP20.11
D+: IC1.4, JP1.4
D+1: IC2.4, JP5.4
D+2: IC3.4, JP9.4
D+3: IC4.4, JP13.4
D+4: IC5.4, JP17.4
D-: IC1.3, JP1.3
D-1: IC2.3, JP5.3
D-2: IC3.3, JP9.3
D-3: IC4.3, JP13.3
D-4: IC5.3, JP17.3
GND: IC1.15, JP2.4
GND1: IC1.23, JP3.1
GND2: IC1.35, JP4.2
GND3: IC1.43, JP4.10
GND4: IC2.15, JP6.4
GND5: IC2.23, JP7.1
GND6: IC2.35, JP8.2
GND7: IC2.43, JP8.10
GND8: IC3.15, JP10.4
GND9: IC3.23, JP11.1
GND10: IC3.35, JP12.2
GND11: IC3.43, JP12.10
GND12: IC4.15, JP14.4
GND13: IC4.23, JP15.1
GND14: IC4.35, JP16.2
GND15: IC4.43, JP16.10
GND16: IC5.15, JP18.4
GND17: IC5.23, JP19.1
GND18: IC5.35, JP20.2
GND19: IC5.43, JP20.10
PB0: IC1.8, JP1.8
PB1: IC1.9, JP1.9
PB2: IC1.10, JP1.10
PB3: IC1.11, JP1.11
PB4: IC1.28, JP3.6
PB5: IC1.29, JP3.7
PB6: IC1.30, JP3.8
PB7: IC1.12, JP2.1
PB8: IC2.12, JP6.1
PB9: IC2.30, JP7.8
PB10: IC2.29, JP7.7
PB11: IC2.28, JP7.6
PB12: IC2.11, JP5.11
PB13: IC2.10, JP5.10
PB14: IC2.9, JP5.9
PB15: IC2.8, JP5.8
PB16: IC3.12, JP10.1
PB17: IC3.30, JP11.8
PB18: IC3.29, JP11.7
PB19: IC3.28, JP11.6
PB20: IC3.11, JP9.11
PB21: IC3.10, JP9.10
PB22: IC3.9, JP9.9
PB23: IC3.8, JP9.8
PB24: IC4.12, JP14.1
PB25: IC4.30, JP15.8
PB26: IC4.29, JP15.7
PB27: IC4.28, JP15.6
PB28: IC4.11, JP13.11
PB29: IC4.10, JP13.10
PB30: IC4.9, JP13.9
PB31: IC4.8, JP13.8
PB32: IC5.12, JP18.1
PB33: IC5.30, JP19.8
PB34: IC5.29, JP19.7
PB35: IC5.28, JP19.6
PB36: IC5.11, JP17.11
PB37: IC5.10, JP17.10
PB38: IC5.9, JP17.9
PB39: IC5.8, JP17.8
PC1: IC2.31, JP7.9
PC2: IC2.32, JP7.10
PC3: IC3.31, JP11.9
PC4: IC3.32, JP11.10
PC5: IC4.31, JP15.9
PC6: IC1.31, JP3.9
PC7: IC1.32, JP3.10
PC8: IC4.32, JP15.10
PC9: IC5.31, JP19.9
PC10: IC5.32, JP19.10
PD0: IC1.18, JP2.7
PD1: IC1.19, JP2.8
PD2: IC1.20, JP2.9
PD3: IC1.21, JP2.10
PD4: IC1.25, JP3.3
PD5: IC1.22, JP2.11
PD6: IC1.26, JP3.4
PD7: IC1.27, JP3.5
PD8: IC2.27, JP7.5
PD9: IC2.26, JP7.4
PD10: IC2.22, JP6.11
PD11: IC2.25, JP7.3
PD12: IC2.21, JP6.10
PD13: IC2.20, JP6.9
PD14: IC2.19, JP6.8
PD15: IC2.18, JP6.7
PD16: IC3.27, JP11.5
PD17: IC3.26, JP11.4
PD18: IC3.22, JP10.11
PD19: IC3.25, JP11.3
PD20: IC3.21, JP10.10
PD21: IC3.20, JP10.9
PD22: IC3.19, JP10.8
PD23: IC3.18, JP10.7
PD24: IC4.27, JP15.5
PD25: IC4.26, JP15.4
PD26: IC4.22, JP14.11
PD27: IC4.25, JP15.3
PD28: IC4.21, JP14.10
PD29: IC4.20, JP14.9
PD30: IC4.19, JP14.8
PD31: IC4.18, JP14.7
PD32: IC5.27, JP19.5
PD33: IC5.26, JP19.4
PD34: IC5.22, JP18.11
PD35: IC5.25, JP19.3
PD36: IC5.21, JP18.10
PD37: IC5.20, JP18.9
PD38: IC5.19, JP18.8
PD39: IC5.18, JP18.7
PE1: IC2.33, JP7.11
PE2: IC1.33, JP3.11
PE3: IC2.1, JP5.1
PE4: IC3.33, JP11.11
PE5: IC3.1, JP9.1
PE6: IC1.1, JP1.1
PE7: IC4.33, JP15.11
PE8: IC4.1, JP13.1
PE9: IC5.33, JP19.11
PE10: IC5.1, JP17.1
PF0: IC1.41, JP4.8
PF1: IC1.40, JP4.7
PF2: IC2.41, JP8.8
PF3: IC2.40, JP8.7
PF4: IC1.39, JP4.6
PF5: IC1.38, JP4.5
PF6: IC1.37, JP4.4
PF7: IC1.36, JP4.3
PF8: IC2.39, JP8.6
PF9: IC2.38, JP8.5
PF10: IC2.37, JP8.4
PF11: IC2.36, JP8.3
PF12: IC3.41, JP12.8
PF13: IC3.40, JP12.7
PF14: IC3.39, JP12.6
PF15: IC3.38, JP12.5
PF16: IC3.37, JP12.4
PF17: IC3.36, JP12.3
PF18: IC4.41, JP16.8
PF19: IC4.40, JP16.7
PF20: IC4.39, JP16.6
PF21: IC4.38, JP16.5
PF22: IC4.37, JP16.4
PF23: IC4.36, JP16.3
PF24: IC5.41, JP20.8
PF25: IC5.40, JP20.7
PF26: IC5.39, JP20.6
PF27: IC5.38, JP20.5
PF28: IC5.37, JP20.4
PF29: IC5.36, JP20.3
RESET: IC1.13, JP2.2
RESET1: IC2.13, JP6.2
RESET2: IC3.13, JP10.2
RESET3: IC4.13, JP14.2
RESET4: IC5.13, JP18.2
UCAP: IC1.6, JP1.6
UCAP1: IC2.6, JP5.6
UCAP2: IC3.6, JP9.6
UCAP3: IC4.6, JP13.6
UCAP4: IC5.6, JP17.6
UGND: IC1.5, JP1.5
UGND1: IC2.5, JP5.5
UGND2: IC3.5, JP9.5
UGND3: IC4.5, JP13.5
UGND4: IC5.5, JP17.5
UVCC: IC1.2, JP1.2
UVCC1: IC2.2, JP5.2
UVCC2: IC3.2, JP9.2
UVCC3: IC4.2, JP13.2
UVCC4: IC5.2, JP17.2
VBUS: IC1.7, JP1.7
VBUS1: IC2.7, JP5.7
VBUS2: IC3.7, JP9.7
VBUS3: IC4.7, JP13.7
VBUS4: IC5.7, JP17.7
VCC: IC1.14, JP2.3
VCC1: IC1.34, JP4.1
VCC2: IC2.14, JP6.3
VCC3: IC2.34, JP8.1
VCC4: IC3.14, JP10.3
VCC5: IC3.34, JP12.1
VCC6: IC4.14, JP14.3
VCC7: IC4.34, JP16.1
VCC8: IC5.14, JP18.3
VCC9: IC5.34, JP20.1
XTAL1: IC1.17, JP2.6
XTAL2: IC1.16, JP2.5
XTAL3: IC2.17, JP6.6
XTAL4: IC2.16, JP6.5
XTAL5: IC3.17, JP10.6
XTAL6: IC3.16, JP10.5
XTAL7: IC4.17, JP14.6
XTAL8: IC4.16, JP14.5
XTAL9: IC5.17, JP18.6
XTAL10: IC5.16, JP18.5

## EAGLE design usb-pickit2-adapter2/usb-pickit2-adapter.brd

Parts:
JP1: PINHD-1X5; 1X05
S2: 2P2T
U$1: TYPE-A+SHILED; TYPE-A
X1: PN87520

Connections:
unnamed: JP1.2, S2.2.1, X1.1
unnamed: JP1.3, U$1.GND (4), X1.4
unnamed: S2.3.1, U$1.VCC (1)
unnamed: JP1.5, U$1.D- (2), X1.2
unnamed: JP1.4, U$1.D+ (3), X1.3
unnamed: JP1.1, U$1.SHEELD (5)

Board: 2 copper layers, 25.4 x 30.5 mm, 4 parts (0 on the bottom side), 6 nets.

## EAGLE design usb-shock-buzzer/usb-shock-buzzer.brd

Parts:
C1, C7: 4.7u; C0805
C2: 0.22u; C0805
C3: 1u; C0805
C4, C5, C6: 0.1u; C0805
CON1: PH-2PIN
IC1: PIC18F14K50; SO20
IC2: ADXL213; LCC8
IC3: AE-NJU72501
IC4: MCP73831; SOT23-5L
IC5: CAT24M01; SOIC
IC6: MAX882SA; 8-SO
JP4: PINHD-1X2; 1X02
JP5: PINHD-2X2; 2X02
LED1: AYBG1202W
LED2: 2COLOR-BR; SML-02
R1: 2.2k; M0805
R2, R3, R7: 10k; M0805
R4: 1M; R0805
R5: 150k; M0805
R6: 470k; M0805
R8: 1M; M0805
R9: 220k?; M0805
R10: 1k; M1206
R11: 1k; M0805
R12: 220k; M0805
R13, R14, R15, R16: 500?; M0805
SP1: PKLCS1212E4001
SW1: TVBP06
USB: TYPE-A+SHILED; TYPE-A
XTAL1: 12MHz; CSTCE

Connections:
BATTERY+: C7.1, CON1.1, IC4.3 (VBAT), IC6.5 (IN), R3.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, CON1.2, IC1.20 (VSS), IC2.3 (COM), IC3.2 (GND1), IC3.4 (GND2), IC4.2 (VSS), IC5.2 (A1), IC5.3 (A2), IC5.4 (GND), IC5.7 (WP), IC6.3 (GND), IC6.6 (GND), LED1.2 (CC1), LED1.4 (CC2), LED2.1 (CC1), LED2.3 (CC2), R1.2, R2.1, R6.1, R9.2, SW1.1, USB.GND (4), XTAL1.2 (GND)
unnamed: IC3.6 (EN1), JP5.2
unnamed: IC1.18 (RA1/D-), USB.D- (2)
unnamed: IC1.19 (RA0/D+), USB.D+ (3)
unnamed: IC4.5 (PROG), R1.1
unnamed: IC1.16 (RC0/AN4), IC4.1 (STAT)
unnamed: JP4.1, USB.SHEELD (5)
unnamed: C2.1, IC1.17 (VUSB)
unnamed: IC1.7 (RC3/AN7), R2.2, R3.1
unnamed: IC6.8 (LBI), R4.1, R5.2
unnamed: IC1.11 (RB6), IC5.6 (SCL)
unnamed: IC1.13 (RB4/AN10), IC5.5 (SDA)
unnamed: C5.1, IC2.6 (YFILT)
unnamed: C6.1, IC2.7 (XFILT)
unnamed: IC1.9 (RC7/AN9), IC2.5 (XOUT)
unnamed: IC1.10 (RB7/TX), IC2.4 (YOUT)
unnamed: IC3.5 (EN2), JP5.4
unnamed: IC2.2 (T2), R9.1
unnamed: IC3.8 (VO1), R10.1, SP1.1
unnamed: IC3.7 (VO2), R10.2, SP1.2
unnamed: IC1.4 (RA3/!MCLR!), JP4.2, R7.1, SW1.2
unnamed: LED1.1 (A1), R13.1
unnamed: LED1.3 (A2), R14.1
unnamed: LED2.4 (AR), R16.1
unnamed: IC1.15 (RC1/AN5), IC3.3 (DIN)
unnamed: IC1.2 (RA5/OSC1), XTAL1.3 (RIT)
unnamed: IC1.14 (RC2/AN6), R15.2
unnamed: IC1.3 (RA4/OSC2), XTAL1.1 (LFT)
unnamed: IC6.2 (SET), R5.1, R6.2
unnamed: IC1.5 (RC5/CCP1), R13.2
unnamed: IC1.6 (RC4/P1B), R14.2
unnamed: IC1.12 (RB5/RX), R16.2
unnamed: LED2.2 (AB), R15.1
unnamed: C3.1, IC6.7 (OFF/STBY), R8.1, R11.2, R12.1
POWERFAIL: IC6.1 (LBO), R12.2
USB_VCC: C1.1, IC4.4 (VDD), R11.1, USB.VCC (1)
VCC: C4.1, IC1.1 (VDD), IC2.8 (VDD), IC3.1 (VIN), IC5.8 (VCC), IC6.4 (OUT), JP5.1, JP5.3, R4.2, R7.2, R8.2

Notes on the sheet:
OUT には 4V 流したい。 SETにかける抵抗は以下で計算する。 4 = 1.2 * (R4+R5+R6)/R6 3V を下回ったら回路を停止したい。 LBIにかける抵抗は以下で計算する。 3 = 1.2 * (R4+R5+R6)/(R5+R6) R4 = 1MΩ と決めてこの方程式を計算すると R5 = 166.66.. kΩ R6 = 500 kΩ 166kΩ と 500kΩ の抵抗はないから 150kΩ, 470kΩ とする R4=1M,R5=150k,R6=470k SET => 1.2*(1000+150+470)/470 = 4.14V LBI => 1.2*(1000+15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

Board: 2 copper layers, 47.0 x 27.0 mm, 38 parts (25 on the bottom side), 38 nets.
